# Keil uVision project stm32l151c8t6a.uvprojx, settings and files
target stm32l151c8t6a (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32l151c8t6a +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\UserHardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c display.c pwr_stop.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group UserHardware
    ../UserHardware/Delay/: delay.c
    ../UserHardware/pcf8563/: pcf8563.c
    ../UserHardware/key/: key.c
    ../UserHardware/si7020/: si7020_iic.c
  group ePaper/Config
    ../UserHardware/ePaper_2in13/Config/: DEV_Config.c EPD_2in13_V2.c
  group ePaper/GUI
    ../UserHardware/ePaper_2in13/GUI/: GUI_Paint.c
  group ePaper/Fonts
    ../UserHardware/ePaper_2in13/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c font80.c font21CN.c
  group ePaper/Example
    ../UserHardware/ePaper_2in13/Example/: ImageData.c EPD_2in13_V2_test.c
software components: CMSIS:CORE 4.3.0
